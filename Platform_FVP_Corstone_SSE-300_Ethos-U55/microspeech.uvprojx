# Keil uVision project microspeech.uvprojx, settings and files
target Example (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28000000,0x00200000) IROM(0x10000000,0x00040000) IROM2(0x00000000,0x00040000) XRAM(0x38200000,0x00200000) XRAM2(0x28200000,0x00200000) XRAM3(0x31000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: microspeech +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: __FVP_PY __EVENT_DRIVEN
  c include: ..\VSI\include;..\VSI\audio\include;..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439,6314
  group App
    ./: microspeech.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group Driver
    ../VSI/audio/driver/: audio_drv.c
  group TF_micro_frontend
    ../micro_speech/src/microfrontend/lib/: fft.cc fft_util.cc filterbank.c filterbank_util.c frontend.c frontend_util.c log_lut.c log_scale.c log_scale_util.c noise_reduction.c noise_reduction_util.c pcan_gain_control.c pcan_gain_control_util.c window.c window_util.c
  group TF_micro_features
    ../micro_speech/src/micro_features/: micro_features_generator.cc micro_model_settings.cc model.cc no_micro_features_data.cc yes_micro_features_data.cc
  group TF_main
    ../micro_speech/src/: audio_provider.cc command_responder.cc feature_provider.cc main.cc main_functions.cc recognize_commands.cc arm_nn_softmax_common_s8.c
  group TF_test
    ../micro_speech/src/: audio_provider_mock.cc micro_speech_test.cc audio_provider_mock_test.cc yes_1000ms_sample_data.cc no_1000ms_sample_data.cc
target Example Test (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: as above
  output: microspeech +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: __FVP_PY __TEST
  c include: ..\VSI\include;..\VSI\audio\include;..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439,6314
target Audio Provider Mock (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: as above
  output: microspeech +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c include: ..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439,6314
target Audio Provider Mock Test (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: as above
  output: microspeech +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: __TEST
  c include: ..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439,6314
software components: CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, CMSIS:NN Lib 3.1.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:GPIO 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:SPI 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Native Driver:Watch Dog 1.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.22.5-rc4, Data Processing:Math:gemmlowp fixed-point 1.22.5-rc4, Data Processing:Math:kissfft 1.22.5-rc4, Data Processing:Math:ruy 1.22.5-rc4, Machine Learning:TensorFlow:Kernel Utils 1.22.5-rc4, Machine Learning:TensorFlow:Kernel 1.22.5-rc4
